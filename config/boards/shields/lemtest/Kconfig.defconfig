## config/boards/shields/lemtest/Kconfig.defconfig
```kconfig
if SHIELD_LEMTEST
           
config ZMK_KEYBOARD_NAME
    default "lemtest"

endif
```
